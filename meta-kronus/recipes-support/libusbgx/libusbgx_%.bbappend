FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-net-Ignore-missing-attributes-when-exporting.patch"

