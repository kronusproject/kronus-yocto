FILESEXTRAPATHS:prepend:mpfs-beaglev-fire := "${THISDIR}/${PN}:"
